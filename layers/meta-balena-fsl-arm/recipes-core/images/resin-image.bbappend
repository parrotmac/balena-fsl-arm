include resin-image.inc

IMAGE_INSTALL_append_nitrogen8mm = " \
        bluetooth-scripts \
"

IMAGE_INSTALL_append_nitrogen8m = " \
        bluetooth-scripts \
"
